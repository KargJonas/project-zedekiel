# Repository KargJonas/project-zedekiel

File README.md:

# project-zedekiel
A pain-free 66% keyboard.

## Flashing Guide
You will need linux for this (yes, when the keyboard is flashed, it will work in windows).
If you are using windows, you might want to take a look at [WSL](https://docs.microsoft.com/en-us/windows/wsl/).

- Clone the Zedekiel QMK fork: `git clone git@github.com:KargJonas/qmk_firmware`
- Open the directory: `cd qmk_firmware`
- Compile and flash Zedekiel default layout: `sudo make zedekiel:default:dfu`

If all goes well, your keyboard should now be ready to use.

## Tools used to make this
- KiCad
- LibreOffice
- LibreCad
- FreeCad
- GIMP
- QMK
- [www.keyboard-layout-editor.com](http://www.keyboard-layout-editor.com/)
- [builder.swillkb.com](http://builder.swillkb.com/)
- [qmk.fm/converter](https://qmk.fm/converter/)
- [www.engbedded.com/fusecalc](https://www.engbedded.com/fusecalc/)

## Resources
- [Keyboard PCB Guide](https://github.com/ruiqimao/keyboard-pcb-guide)
- [keebfol.io List of custom MKs](https://keebfol.io/)
- [QMK Getting Started](https://github.com/qmk/qmk_firmware/blob/76189d9a282cc32bf2ff88a84a6374ebb8908433/docs/getting_started_introduction.md)
- [Understanding QMK](https://github.com/qmk/qmk_firmware/blob/76189d9a282cc32bf2ff88a84a6374ebb8908433/docs/understanding_qmk.md)
- [QMK Keyboard Support](https://beta.docs.qmk.fm/configurator/qmk-api/reference_configurator_support)
- [QMK Config Guide](https://beta.docs.qmk.fm/developing-qmk/c-development/hardware_avr)
- [QMK Keycodes](https://github.com/qmk/qmk_firmware/blob/76189d9a282cc32bf2ff88a84a6374ebb8908433/docs/keycodes.md)
- [QMK ISP Flashing Guide](https://beta.docs.qmk.fm/using-qmk/guides/keyboard-building/isp_flashing_guide)
- [DFU Explained](https://electronics.stackexchange.com/questions/299712/how-is-the-atmega32u4-chip-recognized-via-usb)
- (More in `/misc/resources` folder)

## List of small issues and solutions
- KiCad footprint update not reflecting in 3D viewer =>
  - "e" on footprint
  - Edit footprint from Library
  - Edit footprint properties with the symbol in the topbar of the footprint editor
  - Go back to the pcb editor
  - "e" on footprint
  - Update footprint
  - 3D viewer should automatically update the 3D model
- FreeCad CSV import "broken" => export with {TAB} as delimiter.

# More Pictures

## KiCad design pcb/zedekiel.kicad_pcb

Parts:
C1: 1uF; C_0603
C2, C3: 22pF; C_0603
C4, C5, C6, C7: 100nF; C_0603
C8: 4.7uF; C_0603
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: 1N4148WS; D_SOD-323
K1, K43, K56, K66: KEYSW; Kailh_socket_MX_1.50U
K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K44, K45, K46, K47, K48, K49, K50, K51, K52, K53, K54, K59: KEYSW; Kailh_socket_MX_1.00U
K15: KEYSW; Kailh_socket_MX_1.75U
K28, K60: KEYSW; Kailh_socket_MX_2.25U
K29, K42, K55, K57, K64: KEYSW; Kailh_socket_MX_2.00U
K58, K61, K62, K63, K65: KEYSW; Kailh_socket_MX_1.25U
R1, R6: 10K; R_0603
R2, R3: 5.1K; R_0603
R4, R5: 22; R_0603
SW1: SW_PUSH; pad-button
U1: ATmega16U4-AU_(modified); TQFP-44_10x10mm_Pitch0.8mm
USB1: HRO-TYPE-C; HRO-TYPE-C-31-M-12
X1: 16MHz; Crystal_SMD_5032-2pin_5.0x3.2mm

Connections:
/C1: D1.2 (A), D15.2 (A), D29.2 (A), D43.2 (A), U1.36 (PF7)
/C2: D2.2 (A), D16.2 (A), D30.2 (A), D44.2 (A), D57.2 (A), U1.1 (PE6)
/C3: D3.2 (A), D17.2 (A), D31.2 (A), D45.2 (A), U1.32 (PC7)
/C4: D4.2 (A), D18.2 (A), D32.2 (A), D46.2 (A), D58.2 (A), U1.31 (PC6)
/C5: D5.2 (A), D19.2 (A), D33.2 (A), D47.2 (A), D59.2 (A), U1.27 (PD7)
/C6: D6.2 (A), D20.2 (A), D34.2 (A), D48.2 (A), U1.26 (PD6)
/C7: D7.2 (A), D21.2 (A), D35.2 (A), D49.2 (A), D60.2 (A), U1.22 (PD5)
/C8: D8.2 (A), D22.2 (A), D36.2 (A), D50.2 (A), D61.2 (A), U1.25 (PD4)
/C9: D9.2 (A), D23.2 (A), D37.2 (A), D51.2 (A), U1.21 (PD3)
/C10: D10.2 (A), D24.2 (A), D38.2 (A), D52.2 (A), D62.2 (A), U1.20 (PD2)
/C11: D11.2 (A), D25.2 (A), D39.2 (A), D53.2 (A), D63.2 (A), U1.12 (PB7)
/C12: D12.2 (A), D26.2 (A), D40.2 (A), D54.2 (A), D64.2 (A), U1.30 (PB6)
/C13: D13.2 (A), D27.2 (A), D41.2 (A), D55.2 (A), D65.2 (A), U1.29 (PB5)
/C14: D14.2 (A), D28.2 (A), D42.2 (A), D56.2 (A), D66.2 (A), U1.8 (PB0)
/D+: R4.1, U1.4 (D+)
/D-: R5.1, U1.3 (D-)
/R1: K1.1, K2.1, K3.1, K4.1, K5.1, K6.1, K7.1, K8.1, K9.1, K10.1, K11.1, K12.1, K13.1, K14.1, U1.41 (PF0)
/R2: K15.1, K16.1, K17.1, K18.1, K19.1, K20.1, K21.1, K22.1, K23.1, K24.1, K25.1, K26.1, K27.1, K28.1, U1.40 (PF1)
/R3: K29.1, K30.1, K31.1, K32.1, K33.1, K34.1, K35.1, K36.1, K37.1, K38.1, K39.1, K40.1, K41.1, K42.1, U1.39 (PF4)
/R4: K43.1, K44.1, K45.1, K46.1, K47.1, K48.1, K49.1, K50.1, K51.1, K52.1, K53.1, K54.1, K55.1, K56.1, U1.38 (PF5)
/R5: K57.1, K58.1, K59.1, K60.1, K61.1, K62.1, K63.1, K64.1, K65.1, K66.1, U1.37 (PF6)
ADC11: U1.28 (PB4); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, R2.2, R3.2, R6.2, SW1.1, U1.5 (UGND), U1.15 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD); also elsewhere on the board
MISO: U1.11 (PB3); also elsewhere on the board
MOSI: U1.10 (PB2); also elsewhere on the board
unnamed: C1.1, U1.6 (UCAP)
unnamed: C2.1, U1.17 (XTAL1), X1.1
unnamed: C3.1, U1.16 (XTAL2), X1.2
unnamed: D1.1 (K), K1.2
unnamed: D2.1 (K), K2.2
unnamed: D3.1 (K), K3.2
unnamed: D4.1 (K), K4.2
unnamed: D5.1 (K), K5.2
unnamed: D6.1 (K), K6.2
unnamed: D7.1 (K), K7.2
unnamed: D8.1 (K), K8.2
unnamed: D9.1 (K), K9.2
unnamed: D10.1 (K), K10.2
unnamed: D11.1 (K), K11.2
unnamed: D12.1 (K), K12.2
unnamed: D13.1 (K), K13.2
unnamed: D14.1 (K), K14.2
unnamed: D15.1 (K), K15.2
unnamed: D16.1 (K), K16.2
unnamed: D17.1 (K), K17.2
unnamed: D18.1 (K), K18.2
unnamed: D19.1 (K), K19.2
unnamed: D20.1 (K), K20.2
unnamed: D21.1 (K), K21.2
unnamed: D22.1 (K), K22.2
unnamed: D23.1 (K), K23.2
unnamed: D24.1 (K), K24.2
unnamed: D25.1 (K), K25.2
unnamed: D26.1 (K), K26.2
unnamed: D27.1 (K), K27.2
unnamed: D28.1 (K), K28.2
unnamed: D29.1 (K), K29.2
unnamed: D30.1 (K), K30.2
unnamed: D31.1 (K), K31.2
unnamed: D32.1 (K), K32.2
unnamed: D33.1 (K), K33.2
unnamed: D34.1 (K), K34.2
unnamed: D35.1 (K), K35.2
unnamed: D36.1 (K), K36.2
unnamed: D37.1 (K), K37.2
unnamed: D38.1 (K), K38.2
unnamed: D39.1 (K), K39.2
unnamed: D40.1 (K), K40.2
unnamed: D41.1 (K), K41.2
unnamed: D42.1 (K), K42.2
unnamed: D43.1 (K), K43.2
unnamed: D44.1 (K), K44.2
unnamed: D45.1 (K), K45.2
unnamed: D46.1 (K), K46.2
unnamed: D47.1 (K), K47.2
unnamed: D48.1 (K), K48.2
unnamed: D49.1 (K), K49.2
unnamed: D50.1 (K), K50.2
unnamed: D51.1 (K), K51.2
unnamed: D52.1 (K), K52.2
unnamed: D53.1 (K), K53.2
unnamed: D54.1 (K), K54.2
unnamed: D55.1 (K), K55.2
unnamed: D56.1 (K), K56.2
unnamed: D57.1 (K), K57.2
unnamed: D58.1 (K), K58.2
unnamed: D59.1 (K), K59.2
unnamed: D60.1 (K), K60.2
unnamed: D61.1 (K), K61.2
unnamed: D62.1 (K), K62.2
unnamed: D63.1 (K), K63.2
unnamed: D64.1 (K), K64.2
unnamed: D65.1 (K), K65.2
unnamed: D66.1 (K), K66.2
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R2.1, USB1.4 (CC1)
unnamed: R3.1, USB1.10 (CC2)
unnamed 97: R4.2, USB1.6 (D+), USB1.8 (D+); also elsewhere on the board
unnamed 98: R5.2, USB1.5 (D-), USB1.7 (D-); also elsewhere on the board
unnamed: R6.1, U1.33 (~HWB~/PE2)
SCL: U1.18 (PD0); also elsewhere on the board
SCLK: U1.9 (PB1); also elsewhere on the board
SDA: U1.19 (PD1); also elsewhere on the board
VCC: C4.1, C5.1, C6.1, C7.1, C8.1, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), USB1.2 (VBUS), USB1.11 (VBUS); also elsewhere on the board

Board: 2 copper layers, 304.0 x 95.0 mm, 162 parts (95 on the bottom side), 104 nets.

Other parts of the board:
TP1, TP2, TP3, TP4, TP5, TP6, TP6#2, TP6#3, TP7, TP8, TP9, TP10: TestPoint; single-pad

Their connections:
ADC11: TP7.1; also elsewhere on the board
GND: TP4.1, TP6.1; also elsewhere on the board
MISO: TP8.1; also elsewhere on the board
MOSI: TP9.1; also elsewhere on the board
unnamed 97: TP2.1; also elsewhere on the board
unnamed 98: TP3.1; also elsewhere on the board
SCL: TP6#3.1; also elsewhere on the board
SCLK: TP10.1; also elsewhere on the board
SDA: TP5.1; also elsewhere on the board
VCC: TP1.1, TP6#2.1; also elsewhere on the board

File pcb/assembly/zedekiel-bom.csv:

Designator,Quantity,Value,Footprint,LCSC Part #
"C1, ",1,1uF,0603,C15849
"C2, C3, ",2,22pF,0603,C1653
"C4, C5, C6, C7, ",4,100nF,0603,C14663
"C8, ",1,4.7uF,0603,C19666
"D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, ",66,1N4148WS,SOD-323,C57759
"K1, K43, K56, K66, ",4,KEYSW,custom:Kailh_socket_MX_1.50U,
"K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K44, K45, K46, K47, K48, K49, K50, K51, K52, K53, K54, K59, ",49,KEYSW,custom:Kailh_socket_MX_1.00U,
"K15, ",1,KEYSW,custom:Kailh_socket_MX_1.75U,
"K28, K60, ",2,KEYSW,custom:Kailh_socket_MX_2.25U,
"K29, K42, K55, K57, K64, ",5,KEYSW,custom:Kailh_socket_MX_2.00U,
"K58, K61, K62, K63, K65, ",5,KEYSW,custom:Kailh_socket_MX_1.25U,
"R1, R6, ",2,10K,0603,C25804
"R2, R3, ",2,5.1K,0603,C23186
"R4, R5, ",2,22,0603,C23345
"SW1, ",1,SW_PUSH,custom:pad-button,
"U1, ",1,ATmega16U4-AU_(modified),Housings_QFP:TQFP-44_10x10mm_Pitch0.8mm,C44854
"USB1, ",1,HRO-TYPE-C,Type-C:HRO-TYPE-C-31-M-12,C165948
"X1, ",1,16MHz,Crystals:Crystal_SMD_5032-2pin_5.0x3.2mm,C112572

## KiCad design pcb/zedekiel.backup/zedekiel.kicad_pcb

Parts:
C1: 1uF; C_0603
C2, C3: 22pF; C_0603
C4, C5, C6, C7: 100nF; C_0603
C8: 4.7uF; C_0603
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: 1N4148WS; D_SOD-323
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Amphenol_12401548E4-2A
K1, K43, K56, K66: KEYSW; Kailh_socket_MX_1.50U
K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K44, K45, K46, K47, K48, K49, K50, K51, K52, K53, K54, K59: KEYSW; Kailh_socket_MX_1.00U
K15: KEYSW; Kailh_socket_MX_1.75U
K28, K60: KEYSW; Kailh_socket_MX_2.25U
K29, K42, K55, K57, K64: KEYSW; Kailh_socket_MX_2.00U
K58, K61, K62, K63, K65: KEYSW; Kailh_socket_MX_1.25U
R1, R6: 10K; R_0603
R2, R3: 5.1K; R_0603
R4, R5: 22; R_0603
SW1: SW_PUSH; pad-button
U1: ATmega16U4-AU_(modified); TQFP-44_10x10mm_Pitch0.8mm
X1: 16MHz; Crystal_SMD_5032-2pin_5.0x3.2mm

Connections:
/C1: D1.2 (A), D15.2 (A), D29.2 (A), D43.2 (A), D57.2 (A), U1.36 (PF7)
/C2: D2.2 (A), D16.2 (A), D30.2 (A), D44.2 (A), D58.2 (A), U1.1 (PE6)
/C3: D3.2 (A), D17.2 (A), D31.2 (A), D45.2 (A), D59.2 (A), U1.32 (PC7)
/C4: D4.2 (A), D18.2 (A), D32.2 (A), D46.2 (A), D60.2 (A), U1.31 (PC6)
/C5: D5.2 (A), D19.2 (A), D33.2 (A), D47.2 (A), D61.2 (A), U1.27 (PD7)
/C6: D6.2 (A), D20.2 (A), D34.2 (A), D48.2 (A), D62.2 (A), U1.26 (PD6)
/C7: D7.2 (A), D21.2 (A), D35.2 (A), D49.2 (A), D63.2 (A), U1.22 (PD5)
/C8: D8.2 (A), D22.2 (A), D36.2 (A), D50.2 (A), D64.2 (A), U1.25 (PD4)
/C9: D9.2 (A), D23.2 (A), D37.2 (A), D51.2 (A), D65.2 (A), U1.21 (PD3)
/C10: D10.2 (A), D24.2 (A), D38.2 (A), D52.2 (A), U1.20 (PD2)
/C11: D11.2 (A), D25.2 (A), D39.2 (A), D53.2 (A), U1.12 (PB7)
/C12: D12.2 (A), D26.2 (A), D40.2 (A), D54.2 (A), U1.30 (PB6)
/C13: D13.2 (A), D27.2 (A), D41.2 (A), D55.2 (A), U1.29 (PB5)
/C14: D14.2 (A), D28.2 (A), D42.2 (A), D56.2 (A), D66.2 (A), U1.8 (PB0)
/R1: K1.2, K2.2, K3.2, K4.2, K5.2, K6.2, K7.2, K8.2, K9.2, K10.2, K11.2, K12.2, K13.2, K14.2, U1.41 (PF0)
/R2: K15.2, K16.2, K17.2, K18.2, K19.2, K20.2, K21.2, K22.2, K23.2, K24.2, K25.2, K26.2, K27.2, K28.2, U1.40 (PF1)
/R3: K29.2, K30.2, K31.2, K32.2, K33.2, K34.2, K35.2, K36.2, K37.2, K38.2, K39.2, K40.2, K41.2, K42.2, U1.39 (PF4)
/R4: K43.2, K44.2, K45.2, K46.2, K47.2, K48.2, K49.2, K50.2, K51.2, K52.2, K53.2, K54.2, K55.2, K56.2, U1.38 (PF5)
/R5: K57.2, K58.2, K59.2, K60.2, K61.2, K62.2, K63.2, K64.2, K65.2, K66.2, U1.37 (PF6)
ADC11: U1.28 (PB4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J2.A1, J2.S1, R2.2, R3.2, R6.2, SW1.1, U1.5 (UGND), U1.15 (GND)
MISO: U1.11 (PB3)
MOSI: U1.10 (PB2)
unnamed: C1.1, U1.6 (UCAP)
unnamed: C2.1, U1.17 (XTAL1), X1.1
unnamed: C3.1, U1.16 (XTAL2), X1.2
unnamed: D1.1 (K), K1.1
unnamed: D2.1 (K), K2.1
unnamed: D3.1 (K), K3.1
unnamed: D4.1 (K), K4.1
unnamed: D5.1 (K), K5.1
unnamed: D6.1 (K), K6.1
unnamed: D7.1 (K), K7.1
unnamed: D8.1 (K), K8.1
unnamed: D9.1 (K), K9.1
unnamed: D10.1 (K), K10.1
unnamed: D11.1 (K), K11.1
unnamed: D12.1 (K), K12.1
unnamed: D13.1 (K), K13.1
unnamed: D14.1 (K), K14.1
unnamed: D15.1 (K), K15.1
unnamed: D16.1 (K), K16.1
unnamed: D17.1 (K), K17.1
unnamed: D18.1 (K), K18.1
unnamed: D19.1 (K), K19.1
unnamed: D20.1 (K), K20.1
unnamed: D21.1 (K), K21.1
unnamed: D22.1 (K), K22.1
unnamed: D23.1 (K), K23.1
unnamed: D24.1 (K), K24.1
unnamed: D25.1 (K), K25.1
unnamed: D26.1 (K), K26.1
unnamed: D27.1 (K), K27.1
unnamed: D28.1 (K), K28.1
unnamed: D29.1 (K), K29.1
unnamed: D30.1 (K), K30.1
unnamed: D31.1 (K), K31.1
unnamed: D32.1 (K), K32.1
unnamed: D33.1 (K), K33.1
unnamed: D34.1 (K), K34.1
unnamed: D35.1 (K), K35.1
unnamed: D36.1 (K), K36.1
unnamed: D37.1 (K), K37.1
unnamed: D38.1 (K), K38.1
unnamed: D39.1 (K), K39.1
unnamed: D40.1 (K), K40.1
unnamed: D41.1 (K), K41.1
unnamed: D42.1 (K), K42.1
unnamed: D43.1 (K), K43.1
unnamed: D44.1 (K), K44.1
unnamed: D45.1 (K), K45.1
unnamed: D46.1 (K), K46.1
unnamed: D47.1 (K), K47.1
unnamed: D48.1 (K), K48.1
unnamed: D49.1 (K), K49.1
unnamed: D50.1 (K), K50.1
unnamed: D51.1 (K), K51.1
unnamed: D52.1 (K), K52.1
unnamed: D53.1 (K), K53.1
unnamed: D54.1 (K), K54.1
unnamed: D55.1 (K), K55.1
unnamed: D56.1 (K), K56.1
unnamed: D57.1 (K), K57.1
unnamed: D58.1 (K), K58.1
unnamed: D59.1 (K), K59.1
unnamed: D60.1 (K), K60.1
unnamed: D61.1 (K), K61.1
unnamed: D62.1 (K), K62.1
unnamed: D63.1 (K), K63.1
unnamed: D64.1 (K), K64.1
unnamed: D65.1 (K), K65.1
unnamed: D66.1 (K), K66.1
unnamed: J2.A5, R3.1
unnamed: J2.A6, J2.B6, R4.2
unnamed: J2.A7, J2.B7, R5.2
unnamed: J2.B5, R2.1
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R4.1, U1.4 (D+)
unnamed: R5.1, U1.3 (D-)
unnamed: R6.1, U1.33 (~HWB~/PE2)
SCL: U1.18 (PD0)
SCLK: U1.9 (PB1)
SDA: U1.19 (PD1)
VCC: C4.1, C5.1, C6.1, C7.1, C8.1, J2.A4, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC)

Board: 2 copper layers, 150 parts (0 on the bottom side), 98 nets, no tracks yet.

File zedekiel/zedekiel_bom_jlc.csv:

"Comment","Designator","Footprint","LCSC Part #"
"1uF","C1","C_0603","C15849"
"22pF","C2,C3","C_0603","C1653"
"100nF","C4,C5,C6,C7","C_0603","C14663"
"4.7uF","C8","C_0603","C19666"
"1N4148WS","D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30,D31,D32,D33,D34,D35,D36,D37,D38,D39,D40,D41,D42,D43,D44,D45,D46,D47,D48,D49,D50,D51,D52,D53,D54,D55,D56,D57,D58,D59,D60,D61,D62,D63,D64,D65,D66","D_SOD-323","C57759"
"10K","R1,R6","R_0603","C25804"
"5.1K","R2,R3","R_0603","C23186"
"22","R4,R5","R_0603","C23345"
"ATmega16U4-AU_(modified)","U1","TQFP-44_10x10mm_Pitch0.8mm","C44854"
"16MHz","X1","Crystal_SMD_5032-2pin_5.0x3.2mm","C112572"

## Commit log

2020-03-29 Added some stl files
2020-04-06 Rounding for the screw protusions, foot part
2020-04-23 Wood case, misc changes
2020-06-10 work on schematic/pcb
2020-06-20 Custom Footprints. Work in PCB.
2020-06-20 Diodes and sockets in place
2020-06-20 Holes and stabilizers
2020-06-21 Routing started.
2020-06-21 Routing. Fixed a moved socket.
2020-06-21 Fixed another socket
2020-06-21 Pads
2020-06-21 Progress, I guess..
2020-06-24 working on better routing
2020-06-24 better routing for the switch matrix
2020-06-26 more routing
2020-06-26 routing improvements
2020-06-27 almost done with routing
2020-06-29 basically done with routing
2020-06-30 done with routing
2020-06-30 labeling & silk screen art
2020-06-30 signarue
2020-07-01 starting to add 3d models
2020-07-02 added some more models
2020-07-02 project tree restructured, finished adding models
2020-07-02 added the switch position document
2020-07-02 added a librecad scketch of the pcb
2020-07-02 cleaned up the project, added a readme
2020-07-02 added versions of sockets with/without switches
2020-07-02 added one more render to the readme
2020-07-04 proper passhthough holes, better hole indicators, updated 3d model paths, freecad export of pcb
2020-07-05 designing the new case
2020-07-05 low case finished, test assembly
2020-07-05 switch plate, assembly, render attempt
2020-07-06 progress on the case
2020-07-07 finished the case, minor change on pcb
2020-07-07 cleaned up the filetree a bit
2020-07-08 getting the pcb ready for manufacture
2020-07-10 minor changes
2020-07-12 trying to get the assembly files to work
2020-07-12 got a working manufacturing export
2020-07-27 Fixed a problem on the pcb, updated readme
2020-07-31 Updated layout
2020-10-17 restructured the parts library
2020-10-31 Added images of the working prototype
2020-10-31 Fixed the image file format
2020-10-31 Rotated the top view image
